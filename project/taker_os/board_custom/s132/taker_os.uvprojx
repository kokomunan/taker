# Keil uVision project taker_os.uvprojx, settings and files
target 52832_debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: taker_os
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD __STACK_SIZE=4096 __HEAP_SIZE=1024 NRF52832 BOARD_CUSTOM NRF_SD_BLE_API_VERSION=3 S132 NRF52 SOFTDEVICE_PRESENT FREERTOS DEBUG
  c include: .\config;..\..\config;..\..\..\..\project;..\..\..\..\components\ble\ble_advertising;..\..\..\..\components\ble\ble_error_log;..\..\..\..\components\boards;..\..\..\..\components\ble\ble_dtm;..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\components\ble\ble_dtm;..\..\..\..\components\ble\ble_debug_assert_handler;..\..\..\..\components\ble\common;..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\components\ble\peer_manager;..\..\..\..\components\device;..\..\..\..\components\drivers_nrf\common;..\..\..\..\components\drivers_nrf\clock;..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\components\drivers_nrf\uart;..\..\..\..\components\toolchain\arm;..\..\..\..\components\toolchain\cmsis;..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\components\libraries\bsp;..\..\..\..\components\libraries\fstorage;..\..\..\..\components\libraries\util;..\..\..\..\components\drivers_nrf\hal;..\..\..\..\components\device;..\..\..\..\components\ble\ble_racp;..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\components;..\..\..\..\components\ble\common;..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\components\ble\peer_manager;..\..\..\..\components\libraries\button;..\..\..\..\components\libraries\fds;..\..\..\..\components\libraries\log\src;..\..\..\..\external\freertos\config;..\..\..\..\external\freertos\source\include;..\..\..\..\components\toolchain\cmsis\include;..\..\..\..\components\drivers_nrf\delay;..\..\..\..\components\libraries\sensorsim;..\..\..\..\components\libraries\log\src;..\..\..\..\components\libraries\timer;..\..\..\..\components\libraries\fstorage;..\..\..\..\components\libraries\hardfault;..\..\..\..\components\libraries\util;..\..\..\..\components\libraries\log;..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\components\ble\ble_services\ble_robotpen_dis;..\..\app;..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\components\softdevice\s132\headers;..\..\..\..\components\drivers_ext\battery;..\..\..\..\components\drivers_ext\flash_ext;..\..\..\..\components\drivers_ext\jedi;..\..\..\..\components\drivers_ext\key;..\..\..\..\components\drivers_ext\led;..\..\..\..\components\drivers_ext\rtc_ext;..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\components\drivers_ext\flash_ext;..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\components\drivers_nrf\twi_master\deprecated\config;..\..\..\..\components\drivers_nrf\twi_master\deprecated;..\..\..\..\components\drivers_ext\jedi;..\..\..\..\components\libraries\queue;..\..\..\..\components\libraries\hardfault\nrf52\handler;..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\components\drivers_nrf\hal
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x50000
  memory RVCT9: RAM 0x20002e28 size 0xd1d8
  group Application
    ../../: main.c
    ./config/: sdk_config.h
    ../../app/: app_config.h
    ../../../../components/boards/: custom_board.h
  group app
    ../../app/: entry_thread.c main_deamon.c ble_statck_thread.c input_thread.c server_thread.c power_thread.c ble_client_response.c ble_server.c note_manager.c env.c get_position.c
  group soc device
    ../../../../components/toolchain/: system_nrf52.c
    ../../../../components/toolchain/arm/: arm_startup_nrf52.s
  group drivers_ext
    ../../../../components/drivers_ext/battery/: battery.c
    ../../../../components/drivers_ext/flash_ext/: ext_flash.c
    ../../../../components/drivers_ext/jedi/: jedi_device.c
    ../../../../components/drivers_ext/rtc_ext/: ex_rtc.c
    ../../../../components/drivers_ext/key/: key.c
    ../../../../components/drivers_ext/led/: LED.c
  group third parties
    ../../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../external/freertos/source/portable/MemMang/: heap_1.c
    ../../../../external/freertos/portable/ARM/nrf52/: port.c
    ../../../../external/freertos/portable/CMSIS/nrf52/: port_cmsis_systick.c port_cmsis.c
  group nRF_BLE
    ../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
  group nRF_Ble_Services
    ../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../components/ble/ble_services/ble_nus/: ble_nus.c
    ../../../../components/ble/ble_services/ble_robotpen_dis/: ble_robotpen_dis.c
  group nRF_Drivers
    ../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../components/drivers_nrf/spi_master/: nrf_drv_spi.c spi_bus.c
    ../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c tiw_bus.c
    ../../../../components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../../../../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../../../components/drivers_nrf/hal/: nrf_saadc.c
  group nRF_Libraies
    ../../../../components/libraries/button/: app_button.c
    ../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../components/libraries/hardfault/nrf51/handler/: hardfault_handler_keil.c
    ../../../../components/libraries/fstorage/: fstorage.c
    ../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../../../../components/libraries/crc16/: crc16.c
    ../../../../components/libraries/timer/: app_timer_freertos.c
    ../../../../components/libraries/queue/: nrf_queue.c
  group nRF_log
    ../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_SoftDevice
    ../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target 52832_release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: taker_os
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000

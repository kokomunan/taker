# Keil uVision project secure_dfu_secure_dfu_ble_s130_pca10028.uvprojx, settings and files
target nrf51422_xxac_s130 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51422_xxac_s130 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION NRF_SD_BLE_API_VERSION=2 S130 BOARD_CUSTOM SWI_DISABLE0 SOFTDEVICE_PRESENT NRF51822 NRF51 NRF_DFU_SETTINGS_VERSION=1
  c include: ..\..\config\secure_dfu_secure_dfu_ble_s130_pca10028;..\..\config;..\..\..\..\..\components;..\..\..\..\..\components\ble\common;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\components\libraries\hci;..\..\..\..\..\components\libraries\log;..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\components\libraries\queue;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\components\libraries\svc;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\components\softdevice\s130\headers;..\..\..\..\..\components\softdevice\s130\headers\nrf51;..\..\..\..\..\components\toolchain;..\..;..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\external\nano-pb;..\config;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_nrf\uart
  asm define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION NRF_SD_BLE_API_VERSION=2 S130 BOARD_PCA10028 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF51422 NRF51 NRF_DFU_SETTINGS_VERSION=1
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__HEAP_SIZE=0,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-DNRF_SD_BLE_API_VERSION=2,-DS130,-DBOARD_PCA10028,-DSWI_DISABLE0,-DSOFTDEVICE_PRESENT,-DNRF51422,-DNRF51,-DNRF_DFU_SETTINGS_VERSION=1
  asm include: ..\..\config\secure_dfu_secure_dfu_ble_s130_pca10028;..\..\config;..\..\..\..\..\components;..\..\..\..\..\components\ble\common;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\components\libraries\hci;..\..\..\..\..\components\libraries\log;..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\components\libraries\queue;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\components\libraries\svc;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\components\softdevice\s130\headers;..\..\..\..\..\components\softdevice\s130\headers\nrf51;..\..\..\..\..\components\toolchain;..\..;..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\external\nano-pb;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x3ac00 size 0x5000
  memory RVCT9: RAM 0x200013b0 size 0x2c50
  group Application
    ../../: dfu-cc.pb.c dfu_public_key.c dfu_req_handling.c main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../components/boards/: boards.c
  group nRF_BLE
    ../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_BLE_DFU
    ../../../../../components/libraries/bootloader/ble_dfu/: nrf_ble_dfu.c
  group nRF_Bootloader
    ../../../../../components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_info.c
    ../../../../../components/libraries/bootloader/dfu/: nrf_dfu.c nrf_dfu_flash.c nrf_dfu_mbr.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../components/libraries/crc32/: crc32.c
    ../../../../../components/libraries/ecc/: ecc.c
    ../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../components/libraries/hci/: hci_mem_pool.c
    ../../../../../components/libraries/crypto/: nrf_crypto.c
    ../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../components/libraries/sha256/: sha256.c
  group nRF_SoftDevice
    ../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group nRF_micro_ecc
    ../../../../../external/micro-ecc/nrf51_keil/armgcc/: micro_ecc_lib_nrf51.lib
  group nano-pb
    ../../../../../external/nano-pb/: pb_common.c pb_decode.c
  group nRF_log
    ../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
